Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: d392bc6c-c3c1-4a34-932c-910676ede715.ifc
Time: 2026-08-11T15:42:29
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcStair, vlieringtrap schaartrap met luik Storax - Schaartrap Feniks 90 700 x 1300mm
In: Bouwlaag
Material: aluminium
Pset_Data - WUID: AgAAANN3BUAGAAAA1eoCAAWxXwAAPHsBAHQGAAD66wIAvusCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIAbOsCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); Hyperlink: https://bcb-online.nl/?WUID=AgAAANN3BUAGAAAA1eoCAAWxXwAAPHsBAHQGAAD66wIAvusCAAMA6gcBAQAAAAEAAAAWCAEBAAAAAgAAAOUHAQEAAAAFAAAA8oEAAAVmuQAAZDAAAManAACjrQAA6dgAAAAA5-wCAAUyWwEA5KcBALtzAADn6gIAbOsCAAIArAkBAQAAAAMAAACaCQEBAAAABAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAEJqAAAFYN8AAGQwAADGpwAAo60AAOnYAAAAAPKBAAAFZrkAAGQwAADGpwAAo60AAOnYAAAAAA)); STABU2: 32.32.11; lengte: 1280 mm; inbouwhoogte: 240 mm; inbouwlengte: 1300 mm; U-waarde: 0,93 w/m²·k; breedte: 680 mm; max. belasting: 200 kg; NAA.K.T: samengesteld_product_generiek; bediening: handmatig; theoretische levensduur: 50; serie: Schaartrap Feniks 90; inbouwbreedte: 700 mm; merk: Storax; beweegbaar: True; brandwerendheid EI2: 90 mm; omranding: staal; luik: staal; trap: schaarladder Storax - Schaarladder 300mm
